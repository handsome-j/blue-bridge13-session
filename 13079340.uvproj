# Keil uVision project 13079340.uvproj, settings and files
target 13079340 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: 13079340 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Head
  group USER
    ./: main.c
  group Head
    ./Head/: ds1302.c ds1302.h onewire.c onewire.h 51_main.c 51_main.h
